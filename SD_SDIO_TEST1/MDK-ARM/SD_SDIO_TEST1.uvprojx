# Keil uVision project SD_SDIO_TEST1.uvprojx, settings and files
target SD_SDIO_TEST1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SD_SDIO_TEST1
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FatFs/src/drivers;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Middlewares/Third_Party/FatFs/src;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  link misc: --diag_suppress=L6329
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
    ../Middlewares/Third_Party/FatFs/src/: ff.c ff_gen_drv.c diskio.c
  group Application/User
    ../Src/: gpio.c fatfs.c usart.c sdio.c main.c bsp_driver_sd.c stm32f1xx_hal_msp.c dma.c user_diskio.c spi.c stm32f1xx_it.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_sd.c stm32f1xx_hal_tim.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_flash.c stm32f1xx_hal_cortex.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_spi.c stm32f1xx_hal_uart.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_ll_sdmmc.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c
software components: CMSIS:CORE 4.1.0
